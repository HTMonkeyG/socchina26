# Keil uVision project socchina26.uvprojx, settings and files
target socchina26 (6220000::V6.22::ARMCLANG)
  device: STM32G474CEUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: socchina26 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ..\..\src;..\..\libraries\stm32g474xx-template\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\..\libraries\stm32g474xx-template\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\libraries\stm32g474xx-template\Drivers\CMSIS\Include;..\..\libraries\stm32g474xx-template\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\libraries\dc2;..\cubemx\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32g474xx_flash.sct
  group libraries/stm32g474xx-template
    ../../libraries/stm32g474xx-template/Drivers/MDK-ARM/: startup_stm32g474xx.s
  group src/backend
    ../../src/backend/: entrypoint.c libstm32g4xx.lib
  group projects/cubemx
    ../cubemx/Core/Src/: main.c system_stm32g4xx.c stm32g4xx_hal_msp.c stm32g4xx_it.c gpio.c adc.c spi.c usart.c dma.c hrtim.c
  group src/backend/sample
    ../../src/backend/sample/: sample.c sample.h fft.c
  group src/shared
    ../../src/shared/: binaryStream.c binaryStream.h
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2
